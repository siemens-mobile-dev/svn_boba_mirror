# IAR project MegaDial.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: obexcopy.exe E:\ARM\MegaDial\Release\Exe\MegaDial.elf \MMCard\ZBin\Daemons\MegaDial.elf
  XLINK.XclFile: E:\ARM\MegaDial\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: func.asm main.c
