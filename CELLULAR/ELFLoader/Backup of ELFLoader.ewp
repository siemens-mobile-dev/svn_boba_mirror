# IAR project Backup of ELFLoader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: ..\!bin\elf2vkp debug\exe\elfloader.elf elfloader.vkp ..\!ff\s75_32.bin
  XLINK.XclFile: ELFLoader_lnk.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  postbuild: ..\!bin\elf2vkp release\exe\elfloader.elf elfloader.vkp ..\!ff\s75_32.bin
  group (top)
    ./: elfloader.cpp ELFLoader_lnk.xcl elfloader_s.s
