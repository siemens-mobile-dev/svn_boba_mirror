# IAR project BLIBinfo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: dl-stnl0.r79
  XLINK.XclFile: lnk0t.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG; NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: obexcopy Release\Exe\BLIBinfo.elf \MMCard\BLIBinfo.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: func.asm main.c
