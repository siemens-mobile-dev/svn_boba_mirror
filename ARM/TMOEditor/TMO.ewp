# IAR project TMO.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: upload2phone.cmd
  XLINK.XclFile: E:\IARProj\TMOEditor\tmo.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NewSGold (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: upload2phone.cmd
  XLINK.XclFile: E:\IARProj\TMOEditor\tmo.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGold (ARM)
  as the first configuration, except:
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: upload2phone.cmd
  XLINK.XclFile: E:\IARProj\TMOEditor\tmo.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: conf_loader.c conf_loader.h config_data.c func.asm main.c tmo.xcl
    ../inc/: gpslogger_ipc.h
