# IAR project PANDEMONIUM.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NewSGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  group (top)
    ./: conf_loader.c config_data.c cpp.c cpp2.cpp csm.cpp daemonlist.cpp dialog.cpp func.asm gui.cpp iconpack.cpp list.cpp main.c rect_patcher.cpp string_util.cpp
