# IAR project GPView.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: C:\Program Files\totalcmd65\Plugins\wfx\VSOFS\obexcopy.exe E:\IARProj\GPView\Release\Exe\GPView.elf \MMCard\ZBin\Kibab\GPView.elf
  XLINK.XclFile: E:\IARProj\GPView\GPView.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: func.asm main.c
    ../mplayer/: mplayer.c
