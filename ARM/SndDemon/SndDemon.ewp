# IAR project SndDemon.ewp, settings and files
configuration Release ELKA (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: ELKA; NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: ZBin\1.bat SndDemon_ELKA
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release SGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NOHEADSET
  AARM.ADefines: NOHEADSET
  postbuild: ZBin\1.bat SndDemon_SG
configuration Release X75 no headset (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: X75; NOHEADSET
  postbuild: ZBin\1.bat SndDemon_SGx75
configuration Release NEWSGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD
  postbuild: ZBin\1.bat SndDemon_NSG
  group (top)
    ./: conf_loader.c config_data.c func.asm main.c player_tags.c snd_buffers.c some_utils.c speech_txt.c
