# IAR project ELFLoader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: ..\!bin\elf2vkp debug\exe\elfloader.elf elfloader.vkp ..\!ff\s75_32.bin
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: E:\ARM\elfloader\ELFLoader\ELFLoader_lnk.xcl
  group (top)
    ./: elfloader.cpp ELFLoader_lnk.xcl ESI.asm IMB.asm rets.asm
