# IAR project ElfLoader_IAR_old.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  postbuild: ..\!bin\elf2vkp debug\exe\elfloader.elf elfloader.vkp ..\!ff\s75_32.bin
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD
  XLINK.XclFile: ELFLoader_lnk.xcl
configuration Release SGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.AExtraOptionsV2: -j
  XLINK.XclFile: ELFLoader_lnk_SGOLD.xcl
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD; ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD; ELKA
  XLINK.XclFile: ELFLoader_ELKA.xcl
  group (top)
    ./: additional.c elfloader.cpp ESI.asm EXT2.asm FSWI.asm IMB.asm png.c rets.asm
