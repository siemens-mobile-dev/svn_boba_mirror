# IAR project mc.ewp, settings and files
configuration Release_SGOLD (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: postbuild.cmd $EXE_DIR$ Data\ZBin\mc mc.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  postbuild: postbuild.cmd $EXE_DIR$ MMCard\ZBin\mc mc.elf
configuration Release_NEWSGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  postbuild: postbuild.cmd $EXE_DIR$ MMCard\ZBin\mc mc.elf
  group (top)
    ./: Bookmarks.c ColorMap.c ColorMap.h conf_loader.c config.c config.h config_data.c dprop.c exts.c FileOp.c fn_list.c fprop.c fslib.c func.asm gui.c gui.h keys.c krnl.c lng.h main.c mc.h menus.c mui.c mui.h slib.c sort.c TextInput.c
