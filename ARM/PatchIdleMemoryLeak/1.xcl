-carm
-Z(CODE)ICODE=A007A000-A007A0FF
-Z(CODE)PATCH=A04EB9B0-A04EB9B9

-Z(CODE)PATCH_CLOSE_IDLE_GUI=A02FDC7A-A02FDC7B

