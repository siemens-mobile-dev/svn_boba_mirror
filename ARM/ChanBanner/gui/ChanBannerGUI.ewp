# IAR project ChanBannerGUI.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD
  postbuild: obexcopy.exe Release\Exe\ChanBannerGUI.elf \MMCard\ZBin\utilities\ChanBannerGUI.elf
  XLINK.XclFile: ..\1.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: func.asm main.c
