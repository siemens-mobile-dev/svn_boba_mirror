# IAR project zlib_deflate.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: dl-stnl0.r79
  XLINK.XclFile: lnk0t.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
  group (top)
    ./: adler32.c crc32.c crc32.h deflate.c deflate.h trees.c trees.h zutil.h
