# IAR project MailDaemon.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: obexcopy $EXE_DIR$\$PROJ_FNAME$.elf \Data\Zbin\$PROJ_FNAME$.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release (ARM)
  as the first configuration, except:
  postbuild: obexcopy $EXE_DIR$\$PROJ_FNAME$.elf \Data\Zbin\EMailClient\$PROJ_FNAME$.elf
configuration Release_NEWSGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD
  postbuild: obexcopy $EXE_DIR$\$PROJ_FNAME$.elf \MMCard\Zbin\Daemons\$PROJ_FNAME$.elf
  group (top)
    ../: conf_loader.c config_data.c
    ./: func.asm main.c
