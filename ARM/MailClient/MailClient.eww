<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MailDaemon\MailDaemon.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\MailViewer\MailViewer.ewp</path>
  </project>
  <batchBuild/>
</workspace>


