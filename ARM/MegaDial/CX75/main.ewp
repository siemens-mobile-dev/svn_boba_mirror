# IAR project main.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: G:\Projects\ARM\CX75\Dialer\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  postbuild: Release\Exe\hex2vkp -f"D:\My Downloads\x75\IDB\1.bin" Release\Exe\main.hex
  XLINK.XclFile: E:\ARM\MegaDial\CX75\1.xcl
  group (top)
    ./: ESI.asm func.asm main.c patch.asm
