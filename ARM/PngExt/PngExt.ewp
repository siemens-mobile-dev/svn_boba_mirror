# IAR project PngExt.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: CX70
  postbuild: elf2vkp $TARGET_PATH$ $TARGET_DIR$\$PROJ_FNAME$.vkp ..\!ff\cx70_56.bin
  XLINK.XclFile: PhgExt.xcl
configuration Release_SL65 (ARM)
  as the first configuration, except:
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: SL65
  postbuild: as above
  XLINK.XclFile: PhgExt_sl65.xcl
  group (top)
    ./: func.asm main.c png.c
