# IAR project IDLEHOOK.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: obexcopy.exe E:\ARM\IDLEHOOK\Release\Exe\CpuMon.elf \MMCard\ZBin\Daemons\CpuMon.elf
  XLINK.XclFile: E:\ARM\IDLEHOOK\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: main.c
