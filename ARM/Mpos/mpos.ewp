# IAR project mpos.ewp, settings and files
configuration Release_cx75_13 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD
  XLINK.XclFile: mpos_cx75_13.xcl
configuration Release_sk65_50 (ARM)
  as the first configuration, except:
  XLINK.XclFile: mpos_sk65_50.xcl
  group (top)
    ./: additional.c main.asm mpos_cx75_13.xcl mpos_sk65_50.xcl
