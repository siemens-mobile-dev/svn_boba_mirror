# IAR project LogSms.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: dl-stnl0.r79
  XLINK.XclFile: lnk0t.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG; NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD
  postbuild: "obexcopy.exe" Release\Exe\LogSms.elf \MMCard\ZBin\Daemons\LogSms.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: conf_loader.c config.c func.asm main.c
