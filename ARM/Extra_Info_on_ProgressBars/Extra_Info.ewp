# IAR project Extra_Info.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD
  postbuild: ..\elfloader\elf2vkp.exe $EXE_DIR$\$PROJ_FNAME$.elf $EXE_DIR$\$PROJ_FNAME$.vkp C:\\1.bin
  XLINK.XclFile: cx75_13.xcl
  group (top)
    ./: additional.c conf_loader.c config_data.c cx75_13.xcl main.asm rets_CX75sw13.asm
