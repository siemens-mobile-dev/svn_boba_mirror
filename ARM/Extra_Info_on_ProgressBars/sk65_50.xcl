-carm
-Z(CODE)CODE,DATA_C,CONFIG_DATA_C=A0FC7D00-FFFFFFFF

-Z(CODE)PATCH_ENTER3=A0B40464-A0B40467
