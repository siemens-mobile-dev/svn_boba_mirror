-carm
-Z(CODE)START,CODE,SWITAB,INITTAB,DATA_ID,DATA_C=A0FCE000-FFFFFFFF

-Z(CODE)PATCH_START_ELF=A04B0A80-A04B0A83