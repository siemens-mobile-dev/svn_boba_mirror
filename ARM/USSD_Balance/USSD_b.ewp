# IAR project USSD_b.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release NEW (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD
  group (top)
    ./: conf_loader.c config_data.c func.asm main.c
