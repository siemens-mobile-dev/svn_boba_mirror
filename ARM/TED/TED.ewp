# IAR project TED.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: obexcopy.exe Release\Exe\TED.elf \MMCard\ZBin\TED\TED.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpraw
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: as above
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpraw
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: as above
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpraw
  group (top)
    ./: config_data.c convert_format.c convert_simple.c div.r79 func.asm linework.c main.c saver.c
