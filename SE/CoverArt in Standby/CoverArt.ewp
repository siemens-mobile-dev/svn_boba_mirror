# IAR project CoverArt.ewp, settings and files
configuration RU (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: NDEBUG
  ICCARM.PreInclude: LNG-RU.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration EN (ARM)
  as the first configuration, except:
  ICCARM.PreInclude: LNG-EN.h
configuration Release (ARM)
  as the first configuration, except:
  group (top)
    ../C++/: _cpp2.cpp
    ./: Animation.c book.c conf_loader.cpp config_data.c CurrentTrack.c decoder2.c DecoderInit.c draw.c encoding.c Images.c labels.c main.cpp scrolling.c Standby.c string.c tag_reset.c
    ../include/: func.asm
