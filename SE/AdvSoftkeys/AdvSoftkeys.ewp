# IAR project AdvSoftkeys.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group (top)
    $EW_DIR$/projects/C++/: _cpp2.cpp
    ./: books.cpp cfg.cpp draw.cpp images.cpp iofunc.cpp key.cpp main.cpp mybook.cpp presets.cpp redraw.cpp soft_funcs.cpp softkeys.cpp string.cpp ui.cpp untar.cpp xml.cpp
    $EW_DIR$/projects/include/: func.asm
