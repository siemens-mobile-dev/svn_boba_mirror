# IAR project main.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: F:\Projects\ARM\se\BookManeger\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: ..\include\1.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ../C++/: _cpp2.cpp
    ../include/: func.asm
    ./: main.c
