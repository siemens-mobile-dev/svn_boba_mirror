# IAR project ElfPack.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  XLINK.XclFile: 1.xcl
configuration K750_R1CA021 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: K750_R1CA021; SWI_HOOK
  ICCARM.PreInclude: Target\K750_R1CA021.h
  AARM.ADefines: K750_R1CA021; SWI_HOOK
  XLINK.XclFile: xcl\K750_R1CA021.xcl
configuration W810_R4EA031 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: W810_R4EA031; SWI_HOOK
  ICCARM.PreInclude: Target\W810_R4EA031.h
  AARM.ADefines: W810_R4EA031; SWI_HOOK
  XLINK.XclFile: xcl\W810_R4EA031.xcl
configuration Z550_R6CA009 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: Z550_R6CA009; SWI_HOOK
  ICCARM.PreInclude: Target\Z550_R6CA009.h
  AARM.ADefines: Z550_R6CA009; SWI_HOOK
  XLINK.XclFile: xcl\Z550_R6CA009.xcl
configuration W800_R1BC002 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: W800_R1BC002; SWI_HOOK
  ICCARM.PreInclude: Target\W800_R1BC002.h
  AARM.ADefines: W800_R1BC002
  XLINK.XclFile: xcl\W800_R1BC002.xcl
configuration W810_R4DB005 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: W810_R4DB005; SWI_HOOK
  ICCARM.PreInclude: Target\W810_R4DB005.h
  AARM.ADefines: W810_R4DB005
  XLINK.XclFile: xcl\W810_R4DB005.xcl
configuration W700_R1CA021 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: W700_R1CA021; SWI_HOOK
  ICCARM.PreInclude: Target\W700_R1CA021.h
  AARM.ADefines: W700_R1CA021; SWI_HOOK
  XLINK.XclFile: xcl\W700_R1CA021.xcl
configuration K600_R2BB001 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: K600_R2BB001; SWI_HOOK; DAEMONS_INTERNAL
  ICCARM.PreInclude: Target\K600_R2BB001.h
  AARM.ADefines: K600_R2BB001; SWI_HOOK
  XLINK.XclFile: xcl\K600_R2BB001.xcl
configuration W580_R8BA024 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DB2020; W580_R8BA024; SWI_HOOK
  ICCARM.PreInclude: Target\W580_R8BA024.h
  AARM.ADefines: W580_R8BA024; SWI_HOOK
  XLINK.XclFile: xcl\W580_R8BA024.xcl
configuration W800_R1BD001 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: W800_R1BD001; SWI_HOOK
  ICCARM.PreInclude: Target\W800_R1BD001.h
  AARM.ADefines: W800_R1BD001; SWI_HOOK
  XLINK.XclFile: xcl\W800_R1BD001.xcl
configuration Z610_R6DA001 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DB2020; Z610_R6DA001; SWI_HOOK
  ICCARM.PreInclude: Target\Z610_R6DA001.h
  AARM.ADefines: Z610_R6DA001; SWI_HOOK
  XLINK.XclFile: xcl\Z610_R6DA001.xcl
configuration W850_R1KG001 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DB2020; W580_R8BA024; SWI_HOOK
  ICCARM.PreInclude: Target\W580_R8BA024.h
  AARM.ADefines: W580_R8BA024; SWI_HOOK
  XLINK.XclFile: xcl\W850_R1KG001.xcl
  group (top)
    ./: calls.asm elfloader.cpp helper.c InternalFunc.c regfile.c swi.asm
  group ASM
    asm/: K600_R2BB001.asm K750_R1CA021.asm W580_R8BA024.asm W700_R1CA021.asm W800_R1BC002.asm W800_R1BD001.asm W810_R4DB005.asm W810_R4EA031.asm W850_R1KG001.asm Z550_R6CA009.asm Z610_R6DA001.asm
