# IAR project dynconst.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106        Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
configuration Z610_R6DA001 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  prebuild: mkinctmp.exe Z610_R6DA001
configuration K600_R2BB001 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default        None
  ICCARM.CCDefines: NDEBUG
  prebuild: mkinctmp.exe K600_R2BB001
configuration K750_R1CA021 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default        None
  ICCARM.CCDefines: NDEBUG
  prebuild: mkinctmp.exe K750_R1CA021
configuration W550_R4CB020 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default        None
  ICCARM.CCDefines: NDEBUG
  prebuild: mkinctmp.exe W550_R4CB020
configuration W580_R8BA024 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default        None
  ICCARM.CCDefines: NDEBUG
  prebuild: mkinctmp.exe W580_R8BA024
configuration W610_R6BC002 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default        None
  ICCARM.CCDefines: NDEBUG
  prebuild: mkinctmp.exe W610_R6BC002
configuration W660_R8BB001 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default        None
  ICCARM.CCDefines: NDEBUG
  prebuild: mkinctmp.exe W660_R8BB001
configuration W700_R1CA021 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default        None
  ICCARM.CCDefines: NDEBUG
  prebuild: mkinctmp.exe W700_R1CA021
configuration W800_R1BD001 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default        None
  ICCARM.CCDefines: NDEBUG
  prebuild: mkinctmp.exe W800_R1BD001
configuration W810_R4EA031 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default        None
  ICCARM.CCDefines: NDEBUG
  prebuild: mkinctmp.exe W810_R4EA031
configuration W850_R1KG001 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default        None
  ICCARM.CCDefines: NDEBUG
  prebuild: mkinctmp.exe W850_R1KG001
configuration Z550_R6CA009 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default        None
  ICCARM.CCDefines: NDEBUG
  prebuild: mkinctmp.exe Z550_R6CA009
configuration W200_R4HA014 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  prebuild: mkinctmp.exe W200_R4HA014
configuration W600_R7CA017 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  prebuild: mkinctmp.exe W600_R7CA017
  group (top)
    ./: main.asm
