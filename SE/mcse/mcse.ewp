# IAR project mcse.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: NDEBUG
  ICCARM.PreInclude: mem.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Debug (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: LOG
  group (top)
    ./: 7zslib.cpp arch.cpp bookmarks.cpp ColorMap.cpp conf_loader.cpp config.cpp config_data.c encode.cpp exts.cpp FileOP.cpp fn_list.cpp fslib.cpp gui.cpp keys.cpp krnl.cpp log.cpp main.cpp mem.cpp menus.cpp mui.cpp quicksort.cpp slib.cpp sort.cpp textinput.cpp zslib.cpp
    ../include/: func.asm
  group 7Z
    7Z/: 7zlib.r79
  group Zlib
    ZLib/: CRC32.C
  group Zlib/minizip
    ZLib/minizip/: crypt.h ioapi.c ioapi.h unzip.c unzip.h zip.c zip.h
