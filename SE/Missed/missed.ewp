# IAR project missed.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106        Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default        None
  ICCARM.CCDefines: NDEBUG
  group (top)
    ../C++/: _cpp2.cpp
    ../include/: func.asm
    ./: missed.c string.cpp string.h util.h
