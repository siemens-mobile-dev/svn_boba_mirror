# IAR project GpsMAP.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  XLINK.XclFile: ..\include\1.xcl
  group (top)
    ../C++/: _cpp2.cpp
    ./: draw.c main.cpp map_object.c pngread.c read_csv.c read_ini.c
    ../include/: func.asm
